# IAR project stm32f4_stdproj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX; xVECT_TAB_SRAM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: inc\; stm32f4-discovery\; stm32fxx_StdPeriph_Driver\inc\; user\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm32f4_stdproj.out
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group startup
    startup/: startup_stm32f4xx.s
  group stm32f4-discovery
    stm32f4-Discovery/: stm32f4_discovery.c
    stm32f4-discovery/: stm32f4_discovery_lis302dl.c
  group stm32fxx_StdPeriph_Driver
    stm32fxx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group user
    user/: flash_usr.c main.c main.h selftest.c selftest.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
